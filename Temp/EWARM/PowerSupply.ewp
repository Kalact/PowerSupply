# IAR project PowerSupply.ewp, settings and files
configuration PowerSupply (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\ILI9341\Inc; ..\Drivers\ILI9341\Src\ILI9341; ..\Drivers\GrowControl; ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\GUI; ..\Drivers\PowerSupply
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: PowerSupply.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c main.c gpio.c rtc.c spi.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/Fonts
    ../Drivers/ILI9341/Src/ILI9341/: 5x5_font.h
  group Application/User/GrowControl
    ../Drivers/GrowControl/: GrowControl.c GrowControl.h Plant.c Plant.h
  group Application/User/GUI
    ../Drivers/GUI/: GUI.c GUI.h
  group Application/User/LCD_Driver
    ../Drivers/ILI9341/Src/ILI9341/: ILI9341_GFX.c ILI9341_GFX.h ILI9341_STM32_Driver.c ILI9341_STM32_Driver.h
  group Application/User/PowerSupply
    ../Drivers/PowerSupply/: PowerSupply.c PowerSupply.h
  group Application/User/Tests
    ../Drivers/Tests/: DisplayTest.c
  group Application/User/Utilits
    ../Src/: gpio.c rtc.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group LCD_ILI9341
    ../Drivers/ILI9341/Src/: gpio.c main.c rng.c spi.c stm32f7xx_hal_msp.c stm32f7xx_it.c tim.c usart.c
    ../Drivers/ILI9341/Src/ILI9341/: ILI9341_Touchscreen.c ILI9341_Touchscreen.h
